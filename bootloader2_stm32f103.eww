<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bootloader2_stm32f103.ewp</path>
    </project>
    <batchBuild />
</workspace>
